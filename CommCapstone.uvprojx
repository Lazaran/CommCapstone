# Keil uVision project CommCapstone.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CommCapstone
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: PLL.c ST7735.c SysTick.c startup.s BluetoothLib.c LEDBTNS.c RadioLib.c main.c CommProtocol.c
